<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Problem1\Problem1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Problem2\Problem2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Problem3\Problem3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Problem4\Problem4.ewp</path>
    </project>
    <batchBuild />
</workspace>
